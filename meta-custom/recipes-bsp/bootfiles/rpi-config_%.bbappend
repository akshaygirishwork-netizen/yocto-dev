RPI_EXTRA_CONFIG:append = "\ndtoverlay=mychardev-overlay\n"